Commit message: Major changes, fk complete

File: urdf/locobot_description_v3.urdf (robot description, URDF)
Before this commit: robot locobot_description_v3, 24 links, 23 joints
Joints:
- joint joint_1: origin xyz=0 0 0.072 rpy=0 0 0 -> xyz=-0.0896 0.0003875 0.159 rpy=0 0 0
